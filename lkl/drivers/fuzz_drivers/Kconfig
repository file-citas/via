## lkl/drivers/fuzz_drivers/Kconfig
```kconfig
config FUZZ_ACPI_MODULE
tristate "Fake module to fuzz acpi"
default m
help
Fake module to fuzz acpi
```
